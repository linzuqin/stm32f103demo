# Keil uVision project Project.uvprojx, settings and files
target C8T6 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ac6demo +hex
  AfterMake: "D:\project\ac6 demo\keil5_disp_size_bar.exe"
  AfterMake: $K\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\RTT;.\Component\modbus\modbus\ascii;.\Component\modbus\modbus\functions;.\Component\modbus\modbus\include;.\Component\modbus\modbus\rtu;.\Component\modbus\slave;.\Component\modbus\modbus;.\Component\modbus\master\inc;.\Component\modbus\master;.\Component\modbus\modbus\tcp;.\Component\PID\inc;.\Component\AT;.\Component\My_OTA;.\Component\Optimize;.\Component\easyflash;.\Component\easyflash\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Start/: system_stm32f10x.c startup_stm32f10x_md.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: sys.c sys.h
  group Hardware
    ./Hardware/: MyRTC.c iwdog.c uart.c spi.c GPIO.c OLED.c OLED_Data.c AT_TASK.c ADC.c TIM.c
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c log.h SEGGER_RTT.h
  group freemodbus/modbus
    ./Component/modbus/modbus/rtu/: mbcrc.c
    ./Component/modbus/modbus/functions/: mbfuncother.c mbutils.c
  group freemodbus/slave
    ./Component/modbus/slave/: mb.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbrtu.c portevent.c portserial.c porttimer.c slave_mb_app.c slave_mb_app.h
    ./Component/modbus/modbus/ascii/: mbascii.c
  group freemodbus/master
    ./Component/modbus/master/: master_mb_app.c sensor_mb_app.c master_function.c master_function.h
    ./Component/modbus/master/inc/: agile_modbus.h agile_modbus_rtu.h agile_modbus_tcp.h
    ./Component/modbus/master/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
  group PID
    ./Component/PID/src/: qpid.c
  group AT
    ./Component/AT/: AT_Function.c AT_Function.h lot_function.c lot_function.h base64.c base64.h hmac_sha1.c hmac_sha1.h onenet.c onenet.h
  group easyflash
    ./Component/easyflash/: user_flash.c
    ./Component/easyflash/port/: ef_port.c
    ./Component/easyflash/src/: easyflash.c ef_env.c ef_utils.c
target ZET6 (6230000::V6.23::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ac6demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\RTT;.\Component\modbus\modbus\ascii;.\Component\modbus\modbus\functions;.\Component\modbus\modbus\include;.\Component\modbus\modbus\rtu;.\Component\modbus\slave;.\Component\modbus\modbus;.\Component\modbus\master\inc;.\Component\modbus\master;.\Component\modbus\modbus\tcp;.\Component\PID\inc;.\Component\AT;.\Component\FlashDB\FAL\inc;.\Component\FlashDB\FlashDB\inc;.\Component\FlashDB;.\Component\My_OTA;.\Component\Optimize;.\Component\ringbufer;.\Component\SFUD\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 6.1.0, Data Exchange:JSON:cJSON 1.7.7, RTOS:kernel 3.1.5
